# Repository tristancollins/HiFi-BabyHuey

File README.md:

# HiFi-BabyHuey

An "Engineer's" Baby Huey EL34 PCB

## BoM

- Included as excel file
- Toroidy power transformer
- Primary Windings output transformers

## Chassis

Schaeffer / FPE files included

## Board size

Width:	329.9460 mm 

Height:	146.5580 mm 

Area:	48356.2259 sq. mm

## Power-up procedure

### Safety first

**Make sure all grounds are connected back to the IEC earth connection, and then that IEC earth pin is connected to the earth pin on your plug.**

### Step 1

- Attach an 8ohm 50W resistor to each channel's speaker terminal.
- Adjust the bias pots (RV303 & RV304, RV403 & RV404) counter-clockwise to limit the bias point on the EL34s.
- Adjust driver current set (RV301 & RV401) to 680r by measuring across the footprint of R302/R402
- DON'T INSTALL VALVES
- Connect a multimeter to a B+ point (R334) and set to 500Vdc setting.
- If you have a second multimeter, connect it to a V_Bias point (R332) and set it to 200Vdc.
- Switch the amplifier on and closely monitor the reading(s) - B+ should be ~430Vdc, V_Bias should be ~125Vdc.
- If so, switch off, unplug and watch the reading(s). B+ should decrease slowly to zero over a few minutes. V_Bias should decrease faster.
- **If neither of these things happen, you have a problem... Stop, unplug everything and get help.**

### Step 2

- Install the valves.
- It's best to have two or three multimeters for this bit. And even better if you have leads with little hooks on the end.
- Hook a multimeter to R334 for B+ and to R332 for the bias voltage.
- Plug the power cable in and switch on and let things settle for 30 secs or so.
- Watch the multimeters - you should read ~400Vdc and ~-125Vdc
- If so, power off.

### Step 3

- Move the multimeters to the bias test points (TP303 & TP304) for the power valves of channel one.
- Switch on, let things warm up and then adjust the trim pots to read 0.4Vdc on each multimeter (change the range if needed).
- Once thats done, **KEEPING ONE HAND IN YOUR POCKET**, move the probes to the other channel (TP403 & TP404) and do the same.
- It will take a few goes going back and forth to get both sides to match.

### Step 4

- **KEEPING ONE HAND IN YOUR POCKET** move the probes of one multimeter to the driver stage, one on TP301 and one on TP302.
- You want to adjust the balance to read zero volts (or as close as you can get - it tends to move around).
- Do this for the other channel.

### Step 5

- Go back and repeat Step 3.

### Step 6

Now take a bunch of readings to make sure everything works and sounds as it should. Use the schematic to work out where these points are on the PCB. Compare with the readings I've made [in square brackets]. There will be variations due to component tolerances and line voltage variation. +/-10% should be fine. 

#### OVERALL

Voltages:

- Measure V_Bias [130.6V]
- Measure V_Driver [17.6V]
- Measure BPlusin [400V]
- Measure V_elevation [50V]
- Optional using scope: Measure ripple on B+ (100x probes!) [TBD]
- Optional using scope: Measure ripple on V_Bias [TBD]

Hum:

- Balance heaters using scope

#### CHANNEL 1

Voltages:

- Measure V_neg [127.5V]
- Measure V_pos [16.4V]
- Measure B+out [400V]

Currents:

- A Measure drop across R334 - divide 10x1000 [?]
- B Measure drop across R333 - divide by 270*1000 [1.16V/270r = 4.3mA]
- C Measure drop across R332 - divide by 270*1000 [3V/270r = 11.1mA]
- D Measure drop across R321 - divide by 390*1000 [0.59V/390r = 1.5mA]
- E Measure drop across R322 - divide by 390*1000 [0.59V/390r = 1.5mA]
- F Measure drop across R308 - divide by 220 [165V/220k = 0.75mA]
- G Measure drop across R309 - divide by 220 [165V/220k = 0.75mA]
- H Measure drop across R305 - divide by 47 [123.7V/47k = 2.63mA]
- Make F+G = 1.5mA by adjusting RV301
- D & E should = 1.7mA according to original schematic [1.5mA is close]
- H should equal V_neg/47k [close]

#### CHANNEL 2

Repeat CHANNEL 1

### Step 7

Go and listen to it.

### Step 8

Tweaking.

The poweramp bias set at 40mA is slightly on the low side according to https://www.vtadiy.com/loadline-calculators/power-stage-calculator/

It could be increased to 50mA.

## KiCad design BabyHuey.kicad_pcb

Parts:
C101: 100n X class; C_Rect_L18.0mm_W6.0mm_P15.00mm_FKS3_FKP3; mpn R463I315040H2M
D101, D102, D103, D104: SF51-B; D_DO-201AD_P15.24mm_Horizontal; mpn SF51-B
J101, J102, J103, J104, J105, J106, J108, J109, J110, J111: Screw_Terminal_01x02; TerminalBlock_Phoenix_PT-1,5-2-5.0-H_1x02_P5.00mm_Horizontal; mpn 5441537
J107: Conn_01x01_Female; SolderWire-1.5sqmm_1x01_D1.7mm_OD3mm
J112, J113: Screw_Terminal_01x06; TerminalBlock_RND_205-00302_1x06_P10.00mm_Horizontal; mpn 282838-6
MH101, MH102, MH103, MH104, MH105, MH106, MH107, MH108: MountingHole; MountingHole_3.2mm_M3
MH109, MH110: MountingHole_Pad; MountingHole_3.2mm_M3_Pad_Via
R101: 10r 5W; R_Axial_Power_L25.0mm_W9.0mm_P30.48mm; mpn RS00510R00FE73

Connections:
/Channel_1/B+A: J112.6; also elsewhere on the board
/Channel_1/B+B: J112.1; also elsewhere on the board
/Channel_1/B+out: J112.4; also elsewhere on the board
/Channel_1/GNFB: J109.2; also elsewhere on the board
/Channel_1/Input: J108.2; also elsewhere on the board
/Channel_1/ULA: J112.5; also elsewhere on the board
/Channel_1/ULB: J112.2; also elsewhere on the board
/Channel_2/B+A: J113.6; also elsewhere on the board
/Channel_2/B+B: J113.1; also elsewhere on the board
/Channel_2/B+out: J113.4; also elsewhere on the board
/Channel_2/GNFB: J111.2; also elsewhere on the board
/Channel_2/Input: J110.2; also elsewhere on the board
/Channel_2/ULA: J113.5; also elsewhere on the board
/Channel_2/ULB: J113.2; also elsewhere on the board
/PowerSupply/Driver+: J105.2; also elsewhere on the board
/PowerSupply/Driver-: J105.1; also elsewhere on the board
/PowerSupply/HV+: J101.1; also elsewhere on the board
/PowerSupply/HV-: J101.2; also elsewhere on the board
/PowerSupply/LV+: J102.1; also elsewhere on the board
/PowerSupply/LV-: J102.2; also elsewhere on the board
/PowerSupply/PowerLED: J106.1; also elsewhere on the board
GNDA: C101.2, D103.1 (K), D104.2 (A), J106.2, J108.1, J109.1, J110.1, J111.1, J112.3, J113.3, R101.1; also elsewhere on the board
Heater+: J103.1, J104.1; also elsewhere on the board
Heater-: J103.2, J104.2; also elsewhere on the board
unnamed: C101.1, D101.2 (A), D102.1 (K), MH109.1, R101.2
unnamed: D101.1 (K), D103.2 (A)
unnamed: D102.2 (A), D104.1 (K)
unnamed: J107.1, MH110.1

Notes on the sheet:
-127.5V
DC Outputs
Ground loop breaker
Channel 2 Input
0 - 275V - 330V / 0.4A
Channel 1 Output Transformer Primary Windings PWPP30W6K6 6.6k Raa 30W 40% UL taps
Earth from IEC inlet
Notes / Questions
400V
To panel-mount LED
6.3V / 7A
16.5V
Channel 1 Input
50V / 0.1A
6.3V / 2A
Audio ground to earth connection
Power Transformer Inputs Toroidy TSTA 0250/001
*should really be a bolt through chassis by IEC inlet
Dedicated AC earth point
Mounting holes
Channel 2 Output Transformer Primary Windings PWPP30W6K6 6.6k Raa 30W 40% UL taps

Parts:
C301: DNP; C_Disc_D5.0mm_W2.5mm_P5.00mm
C302, C303: 220n 630V; C_Rect_L26.5mm_W8.5mm_P22.50mm_MKS4; mpn MKP10-.226305P22
C304, C305: 47u 160V; CP_Radial_D12.5mm_P5.00mm; mpn UPS2C470MHD1TO
C306: 47u 25V; CP_Radial_D5.0mm_P2.50mm; mpn UVR1E470MDD1TD
C307: 47u 450V; CP_Radial_D18.0mm_P7.50mm; mpn EEU-EE2W470S
D301, D302: Red; LED_D3.0mm; mpn 151033RS03000
D303, D304: BZX79C10; D_DO-35_SOD27_P7.62mm_Horizontal; mpn BZX79C10
Q301, Q302, Q303, Q304, Q306, Q307: 2n5551; TO-92_HandSolder; mpn 2N5551
Q305, Q308: STU9HN65M2; TO-251-3_Vertical; mpn STU9HN65M2
R301: DNP; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R302: 680r; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal; mpn LR1F680R
R303: 100k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal; mpn LR1F100K
R304: 470r; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal; mpn LR1F470R
R305: 47k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal; mpn MF0207FRE52-47K
R306, R307, R310, R311, R326, R327: 1k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal; mpn MBB02070C1001FRP
R308, R309: 220k 2W; R_Axial_DIN0414_L11.9mm_D4.5mm_P15.24mm_Horizontal; mpn FMF200FTE52-220K
R312, R313: 1Meg; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal; mpn MF0207FRE52-1M
R314: 22k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal; mpn MF0207FTE52-22K
R315, R316: 220k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal; mpn LR1F220K
R317, R318, R319, R320: 100r; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal; mpn MF0207FRE52-100R
R321, R322: 390r; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal; mpn LR1F390R
R323: 22k 2W; R_Axial_DIN0414_L11.9mm_D4.5mm_P15.24mm_Horizontal; mpn RR02J22KTB
R324, R325: 47k 2W; R_Axial_DIN0414_L11.9mm_D4.5mm_P15.24mm_Horizontal; mpn 5083NW47K00JA100
R328, R329: 10r 1%; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal; mpn LR1F10R
R330, R331: 1k 2W; R_Axial_DIN0414_L11.9mm_D4.5mm_P15.24mm_Horizontal; mpn 5083NW1K000J
R332, R333: 270r; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal; mpn LR1F270R
R334: 10r 2W; R_Axial_DIN0414_L11.9mm_D4.5mm_P15.24mm_Horizontal; mpn G00310R00FE7080
RV301: 1k; Potentiometer_Bourns_3339P_Vertical; mpn 3339P-1-102LF
RV302: 470r; Potentiometer_Bourns_3339P_Vertical; mpn 3339P-1-501LF
RV303, RV304: 50k; Potentiometer_Bourns_3339P_Vertical; mpn 3339P-1-503LF
TP301, TP302, TP303, TP304, TP305: TestPoint; TestPoint_Keystone_5005-5009_Compact; mpn 5006
U301: ECC83; VALVE-ECC-83-1-TC
U302, U303: EL34; Octal

Connections:
/B+: R334.1; also elsewhere on the board
/Channel_1/B+A: R324.2, U302.3 (A); also elsewhere on the board
/Channel_1/B+B: R325.2, U303.3 (A); also elsewhere on the board
/Channel_1/B+DriverA: R308.2, R323.1, R324.1
/Channel_1/B+DriverB: R309.1, R323.2, R325.1
/Channel_1/B+out: C307.1, R334.2; also elsewhere on the board
/Channel_1/CathodeA: R328.1, TP303.1, U302.1 (G3), U302.8 (F1)
/Channel_1/CathodeB: R329.2, TP305.1, U303.1 (G3), U303.8 (F1)
/Channel_1/DriverCathodeA: RV302.1, U301.3 (K)
/Channel_1/DriverCathodeB: RV302.3, U301.8 (K)
/Channel_1/GNFB: C301.2, R301.2; also elsewhere on the board
/Channel_1/GNFBin: C301.1, R301.1, R304.1, R307.2
/Channel_1/GridA: D303.2 (A), Q305.3 (S), Q306.3 (C), R326.1
/Channel_1/GridB: D304.2 (A), Q307.3 (C), Q308.3 (S), R327.1
/Channel_1/Input: R303.2, R306.2; also elsewhere on the board
/Channel_1/LTPI: Q301.3 (C), RV302.2
/Channel_1/PlateA: C303.2, R308.1, TP301.1, U301.1 (A)
/Channel_1/PlateB: C302.2, R309.2, TP302.1, U301.6 (A)
/Channel_1/ScreenA: R330.2, U302.4 (G2)
/Channel_1/ScreenB: R331.1, U303.4 (G2)
/Channel_1/ULA: R330.1; also elsewhere on the board
/Channel_1/ULB: R331.2; also elsewhere on the board
/Channel_1/V_neg: C305.2, D302.1 (K), Q303.1 (E), Q304.1 (E), R302.2, R314.2, R321.2, R322.1, R332.2, RV301.2, RV301.3
/Channel_1/V_pos: C306.1, Q305.2 (D), Q308.2 (D), R315.2, R316.1, R333.2
/V_Bias: R332.1; also elsewhere on the board
/V_Driver: R333.1; also elsewhere on the board
GNDA: C304.1, C305.1, C306.2, C307.2, R303.1, R304.2, R305.2, R310.1, R311.2, R328.2, R329.1, TP304.1; also elsewhere on the board
Heater+: U301.4 (F1), U301.5 (F1), U302.7 (F2), U303.7 (F2); also elsewhere on the board
Heater-: U301.9 (F2), U302.2 (F1), U303.2 (F1); also elsewhere on the board
unnamed: C302.1, R313.2, R318.1
unnamed: C303.1, R312.1, R317.1
unnamed: C304.2, R314.1, RV303.1, RV304.1
unnamed: D301.2 (A), Q301.2 (B), R305.1
unnamed: D301.1 (K), D302.2 (A), Q302.2 (B)
unnamed: D303.1 (K), Q305.1 (G), R317.2
unnamed: D304.1 (K), Q308.1 (G), R318.2
unnamed: Q301.1 (E), Q302.3 (C)
unnamed: Q302.1 (E), R302.1, RV301.1
unnamed: Q303.2 (B), Q306.1 (E), R321.1
unnamed: Q303.3 (C), R315.1, R319.1
unnamed: Q304.2 (B), Q307.1 (E), R322.2
unnamed: Q304.3 (C), R316.2, R320.2
unnamed: Q306.2 (B), R319.2
unnamed: Q307.2 (B), R320.1
unnamed: R310.2, RV303.3
unnamed: R311.1, RV304.3
unnamed: R312.2, RV303.2
unnamed: R313.1, RV304.2
unnamed: R307.1, U301.7 (G)
unnamed: R306.1, U301.2 (G)
unnamed: R326.2, U302.5 (G1)
unnamed: R327.2, U303.5 (G1)

Parts of its further copies:
C401: DNP; C_Disc_D5.0mm_W2.5mm_P5.00mm
C402, C403: 220n 630V; C_Rect_L26.5mm_W8.5mm_P22.50mm_MKS4; mpn MKP10-.226305P22
C404, C405: 47u 160V; CP_Radial_D12.5mm_P5.00mm; mpn UPS2C470MHD1TO
C406: 47u 25V; CP_Radial_D5.0mm_P2.50mm; mpn UVR1E470MDD1TD
C407: 47u 450V; CP_Radial_D18.0mm_P7.50mm; mpn EEU-EE2W470S
D401, D402: Red; LED_D3.0mm; mpn 151033RS03000
D403, D404: BZX79C10; D_DO-35_SOD27_P7.62mm_Horizontal; mpn BZX79C10
Q401, Q402, Q403, Q404, Q406, Q407: 2n5551; TO-92_HandSolder; mpn 2N5551
Q405, Q408: STU9HN65M2; TO-251-3_Vertical; mpn STU9HN65M2
R401: DNP; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R402: 680r; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal; mpn LR1F680R
R403: 100k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal; mpn LR1F100K
R404: 470r; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal; mpn LR1F470R
R405: 47k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal; mpn MF0207FRE52-47K
R406, R407, R410, R411, R426, R427: 1k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal; mpn MBB02070C1001FRP
R408, R409: 220k 2W; R_Axial_DIN0414_L11.9mm_D4.5mm_P15.24mm_Horizontal; mpn FMF200FTE52-220K
R412, R413: 1Meg; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal; mpn MF0207FRE52-1M
R414: 22k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal; mpn MF0207FTE52-22K
R415, R416: 220k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal; mpn LR1F220K
R417, R418, R419, R420: 100r; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal; mpn MF0207FRE52-100R
R421, R422: 390r; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal; mpn LR1F390R
R423: 22k 2W; R_Axial_DIN0414_L11.9mm_D4.5mm_P15.24mm_Horizontal; mpn RR02J22KTB
R424, R425: 47k 2W; R_Axial_DIN0414_L11.9mm_D4.5mm_P15.24mm_Horizontal; mpn 5083NW47K00JA100
R428, R429: 10r 1%; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal; mpn LR1F10R
R430, R431: 1k 2W; R_Axial_DIN0414_L11.9mm_D4.5mm_P15.24mm_Horizontal; mpn 5083NW1K000J
R432, R433: 270r; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal; mpn LR1F270R
R434: 10r 2W; R_Axial_DIN0414_L11.9mm_D4.5mm_P15.24mm_Horizontal; mpn G00310R00FE7080
RV401: 1k; Potentiometer_Bourns_3339P_Vertical; mpn 3339P-1-102LF
RV402: 470r; Potentiometer_Bourns_3339P_Vertical; mpn 3339P-1-501LF
RV403, RV404: 50k; Potentiometer_Bourns_3339P_Vertical; mpn 3339P-1-503LF
TP401, TP402, TP403, TP404, TP405: TestPoint; TestPoint_Keystone_5005-5009_Compact; mpn 5006
U401: ECC83; VALVE-ECC-83-1-TC
U402, U403: EL34; Octal

Connections of its further copies:
/B+: R434.1; also elsewhere on the board
/Channel_2/B+A: R424.2, U402.3 (A); also elsewhere on the board
/Channel_2/B+B: R425.2, U403.3 (A); also elsewhere on the board
/Channel_2/B+DriverA: R408.2, R423.1, R424.1
/Channel_2/B+DriverB: R409.1, R423.2, R425.1
/Channel_2/B+out: C407.1, R434.2; also elsewhere on the board
/Channel_2/CathodeA: R428.1, TP403.1, U402.1 (G3), U402.8 (F1)
/Channel_2/CathodeB: R429.2, TP405.1, U403.1 (G3), U403.8 (F1)
/Channel_2/DriverCathodeA: RV402.1, U401.3 (K)
/Channel_2/DriverCathodeB: RV402.3, U401.8 (K)
/Channel_2/GNFB: C401.2, R401.2; also elsewhere on the board
/Channel_2/GNFBin: C401.1, R401.1, R404.1, R407.2
/Channel_2/GridA: D403.2 (A), Q405.3 (S), Q406.3 (C), R426.1
/Channel_2/GridB: D404.2 (A), Q407.3 (C), Q408.3 (S), R427.1
/Channel_2/Input: R403.2, R406.2; also elsewhere on the board
/Channel_2/LTPI: Q401.3 (C), RV402.2
/Channel_2/PlateA: C403.2, R408.1, TP401.1, U401.1 (A)
/Channel_2/PlateB: C402.2, R409.2, TP402.1, U401.6 (A)
/Channel_2/ScreenA: R430.2, U402.4 (G2)
/Channel_2/ScreenB: R431.1, U403.4 (G2)
/Channel_2/ULA: R430.1; also elsewhere on the board
/Channel_2/ULB: R431.2; also elsewhere on the board
/Channel_2/V_neg: C405.2, D402.1 (K), Q403.1 (E), Q404.1 (E), R402.2, R414.2, R421.2, R422.1, R432.2, RV401.2, RV401.3
/Channel_2/V_pos: C406.1, Q405.2 (D), Q408.2 (D), R415.2, R416.1, R433.2
/V_Bias: R432.1; also elsewhere on the board
/V_Driver: R433.1; also elsewhere on the board
GNDA: C404.1, C405.1, C406.2, C407.2, R403.1, R404.2, R405.2, R410.1, R411.2, R428.2, R429.1, TP404.1; also elsewhere on the board
Heater+: U401.4 (F1), U401.5 (F1), U402.7 (F2), U403.7 (F2); also elsewhere on the board
Heater-: U401.9 (F2), U402.2 (F1), U403.2 (F1); also elsewhere on the board
unnamed: C402.1, R413.2, R418.1
unnamed: C403.1, R412.1, R417.1
unnamed: C404.2, R414.1, RV403.1, RV404.1
unnamed: D401.2 (A), Q401.2 (B), R405.1
unnamed: D401.1 (K), D402.2 (A), Q402.2 (B)
unnamed: D403.1 (K), Q405.1 (G), R417.2
unnamed: D404.1 (K), Q408.1 (G), R418.2
unnamed: Q401.1 (E), Q402.3 (C)
unnamed: Q402.1 (E), R402.1, RV401.1
unnamed: Q403.2 (B), Q406.1 (E), R421.1
unnamed: Q403.3 (C), R415.1, R419.1
unnamed: Q404.2 (B), Q407.1 (E), R422.2
unnamed: Q404.3 (C), R416.2, R420.2
unnamed: Q406.2 (B), R419.2
unnamed: Q407.2 (B), R420.1
unnamed: R410.2, RV403.3
unnamed: R411.1, RV404.3
unnamed: R412.2, RV403.2
unnamed: R413.1, RV404.2
unnamed: R407.1, U401.7 (G)
unnamed: R406.1, U401.2 (G)
unnamed: R426.2, U402.5 (G1)
unnamed: R427.2, U403.5 (G1)

Notes on the sheet:
Local cap placed near to EL34s
Source Followers
1.5A
OT Common connected near to this point
Output Bias
• Could increase the source follower current to 2.4mA - use 270r •• However, lower starts to stress the 2N5551 dissipation limit.
BiasA
Phase Splitter
Populate only one
-127.5V
~16.4V
Cascode BJT CCS
BiasB
0.3A
• What value for Shunt Resistor? 22k or 33k according to forum. 39k is too large.
~11mA per channel -130.6V
Adjust for equal anode voltage
~90mA per channel 400V
GNFB Connection
~400V
123.7V/47k = 2.6mA
3.3A per channel
CSS current set to 1.5mA by reading across R_plates
Notes / Questions
Adjust BiasA and BiasB to read 35-55mA (0.35-0.55V)
• Bias range is -1V to -70V
0.59V/390r = 1.5mA
Rset
~4.3mA per channel 17.6V
Shunt Resistor
Ring-of-two
Heater connector

Parts:
C201, C202: 470u 100V; CP_Radial_D18.0mm_P7.50mm; mpn EST477M100AN5AA
C203, C204: 2200u 25V; CP_Radial_D12.5mm_P5.00mm; mpn 228CKS025M
C205, C210: 47u 450V; CP_Radial_D18.0mm_P7.50mm; mpn EEU-EE2W470S
C206, C211: 47u 160V; CP_Radial_D12.5mm_P5.00mm; mpn UPS2C470MHD1TO
C207: 47u 25V; CP_Radial_D5.0mm_P2.50mm; mpn UVR1E470MDD1TD
C208: 10u 450V; CP_Radial_D16.0mm_P7.50mm; mpn UPM2W100MHD
C209: 10u 160V; CP_Radial_D10.0mm_P5.00mm; mpn 517D106M160CC6AE3
C212: 10u 200V; CP_Radial_D10.0mm_P5.00mm; mpn ECA-2DM100B
D201, D202, D203, D204, D205, D206, D207, D208: UF4007; D_DO-41_SOD81_P7.62mm_Horizontal; mpn UF4007
D209, D210: BZX79C10; D_DO-35_SOD27_P7.62mm_Horizontal; mpn BZX79C10
HS201, HS202: HSE-B20250-040H; mpn HSE-B20250-040H
Q201: FQPF8N60C; TO-220-3_Vertical; mpn FQPF8N60C
Q202: FQPF7P20; TO-220-3_Vertical; mpn FQPF7P20
R201, R203: 22k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal; mpn MF0207FTE52-22K
R202, R204: 1Meg; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal; mpn MF0207FRE52-1M
R205, R210, R212: 330k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal; mpn LR1F330K
R206, R207: 100r; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal; mpn MF0207FRE52-100R
R208: 22r; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal; mpn LR1F22R
R209: 10r; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal; mpn LR1F10R
R211: 47k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal; mpn MF0207FRE52-47K
R213: TBD; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
RV201: 470r; Potentiometer_Bourns_3339P_Vertical; mpn 3339P-1-501LF
RV202: 50k; Potentiometer_Bourns_3339P_Vertical; mpn 3339P-1-503LF
TH201: CL140; RV_Disc_D12mm_W4.8mm_P7.5mm; mpn CL140

Connections:
/B+: C210.1, D209.2 (A), R208.1, R210.1; also elsewhere on the board
/PowerSupply/Driver+: D206.2 (A), D207.1 (K); also elsewhere on the board
/PowerSupply/Driver-: C203.2, C204.1; also elsewhere on the board
/PowerSupply/HV+: D201.2 (A), D204.1 (K); also elsewhere on the board
/PowerSupply/HV-: D202.2 (A), D203.1 (K); also elsewhere on the board
/PowerSupply/LV+: D205.2 (A), D208.1 (K); also elsewhere on the board
/PowerSupply/LV-: C201.1, C202.2; also elsewhere on the board
/PowerSupply/LVin: C201.2, C206.2, D208.2 (A), Q202.2 (D), R203.1
/PowerSupply/PowerLED: R213.1, RV202.1, RV202.2; also elsewhere on the board
/PowerSupply/V_elevation: C212.1, R210.2, R211.1, RV201.2
/V_Bias: C211.2, D210.1 (K), R209.1, R212.1; also elsewhere on the board
/V_Driver: C203.1, C207.1, D206.1 (K), R205.1, R213.2, RV202.3; also elsewhere on the board
GNDA: C202.1, C204.2, C205.2, C206.1, C207.2, C208.2, C209.1, C210.2, C211.1, C212.2, D203.2 (A), D204.2 (A), D205.1 (K), D207.2 (A), R202.2, R204.2, R205.2, R211.2, R212.2; also elsewhere on the board
Heater+: RV201.1; also elsewhere on the board
Heater-: RV201.3; also elsewhere on the board
unnamed: C208.1, R201.2, R202.1, R206.2
unnamed: C209.2, R203.2, R204.1, R207.2
unnamed: D201.1 (K), D202.1 (K), TH201.2
unnamed: D209.1 (K), Q201.1 (G), R206.1
unnamed: D210.2 (A), Q202.1 (G), R207.1
unnamed: C205.1, Q201.2 (D), R201.1, TH201.1
unnamed: Q201.3 (S), R208.2
unnamed: Q202.3 (S), R209.2

Notes on the sheet:
The regulator gives protection to inrush Max V across the 22r resistor is V_Z - V_GS = 10 - 4 = 6 Max current is 6/22 = 270mA
Bleeder
Ripple Filter
* Both FETs are encapsulated in plastic - no isolation pad / shoulders needed - use heat transfer pad / paste
400V
17.6V
10V
Heater Elevation 50V
Bias Voltage
-130.6V
Driver Voltage
6.3VAC
Voltage Doubler
275VAC
Heater Center Tap / Elevation
Notes
Humdinger - adjust for minimum hum
LED brightness adjustment or fixed set resistor
High Voltage
50VAC

Board: 2 copper layers, 329.9 x 146.6 mm, 201 parts (6 on the bottom side), 119 nets.

## Commit log

2021-06-04 initial commit of BabyHuey
2021-12-14 Change channel power filter node net
2021-12-14 heater routing start
2021-12-14 further heather routing
2021-12-14 updated C & D footprints
2021-12-15 Fix rescued symbols
2021-12-15 many updates to layout and schemo fix
2021-12-15 Initial shoddy routing and fixed error on schematic
2021-12-15 more routing
2021-12-18 adding uTracer ESP32 board design
2021-12-27 More routing, tidy up of edge cuts and mounting holes
2021-12-27 Pre-replicate commit. Text labels added
2021-12-27 layout replicated and routing tweaked
2021-12-29 move to v6 and huge changes
2021-12-29 more layout tweaks and tidying. v5 files deleted
2021-12-29 starting to fix DRC errors
2021-12-29 re-positioned resistor, passing DRC a bit better
2021-12-29 layout tweaks and adding net labels
2021-12-30 schematic corrections
2021-12-30 add .gitignore
2021-12-30 update schematic PDF
2022-01-01 updated .gitignore
2022-01-01 update footprint to clear DRC warning
2022-01-01 rotate EL34 sockets back to 0deg
2022-01-01 Trace tweaks, component position tweaks, playing with isolated ground planes
2022-01-01 controversial change: gnd plane to islands...
2022-01-01 minor tweaks and adding pictures
2022-01-02 fix OT silkscreen labels
2022-01-02 more ground plane changes
2022-01-02 DRC net classes attempted
2022-01-02 given up on clever grounding
2022-01-02 updating iBoM
2022-01-03 major re-work of routes, edges, pours
2022-01-03 Rset pot added for CSS
2022-01-03 started on BoM
2022-01-03 started on BoM, minor tweaks
2022-01-05 minor layour tweaks
2022-01-05 new routing for rotated sockets
2022-01-06 more tweaks
2022-01-06 Minor tweaks
2022-01-07 adding chassis files
2022-01-07 further refinements to grounding
2022-01-07 Adding mpns
2022-01-08 updated part numbers
2022-01-08 updated ibom
2022-01-09 adding in humdinger, tidying tracks
2022-01-09 update terminology and terminal positions
2022-01-09 update BoM, files for initial release
2022-01-14 getting close to fabrication
2022-01-14 fixed heater trace width
2022-01-15 re-do clearances
2022-01-15 adding gerbers
2022-01-15 altered chassis top
2022-01-29 First issues found
2022-02-21 Update BoM
2022-02-26 updated heatsink footprint and move to release
2022-02-26 update read me for release
2022-03-16 Add power-up procedure
2022-03-16 update readme formatting
2022-03-16 more readme edits
2022-03-16 updated to include voltages
2022-03-16 updated to correct voltage reading
2022-03-17 fix typo in readme
2022-03-17 more typos fixed
2022-03-19 Adding 3d printed chassis shim
2022-08-04 Adding LTspice model
2023-12-15 Fix ground loop error
2023-12-15 update date on PCB
